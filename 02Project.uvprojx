# Keil uVision project 02Project.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 02Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c queue.c timers.c UART.c LEDs.c queue.h timers.h LEDs.h GPIO_defs.h UART.h gps.c I2C.c MMA8451.c delay.c HMC5883L.c i2c1.c
software components: CMSIS:CORE 4.3.0, Board Support:LED 1.0.0, Device:Startup 2.5.0
